# Keil uVision project myproj.uvproj, settings and files
target E4.1 (5040049::V5.04 update 1 (build 49)::ARMCC)
  device: STM32F407IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: myproj +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,    USE_STDPERIPH_DRIVER
  c include: .\CMSIS;.\Driver;.\Program;.\StdPeriph\inc;.\StdPeriph\src
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Program
    ./Program/: main.c stm32f4xx_it.c global.h
  group Driver
    ./Driver/: key.c key.h led.c led.h NVIC.c NVIC.h timer.c timer.h uart.c uart.h oled.c oled.h lcd.c lcd.h font.h beep.c beep.h
  group StdPeriph
    ./StdPeriph/src/: stm32f4xx_spi.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_gpio.c stm32f4xx_rcc.c misc.c stm32f4xx_exti.c stm32f4xx_syscfg.c
    ./StdPeriph/inc/: stm32f4xx_spi.h stm32f4xx_usart.h stm32f4xx_tim.h stm32f4xx_gpio.h stm32f4xx_rcc.h misc.h stm32f4xx_exti.h stm32f4xx_syscfg.h
  group CMSIS
    ./CMSIS/: core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h startup_stm32f40_41xxx.s stm32f4xx.h system_stm32f4xx.c system_stm32f4xx.h 文件说明.txt stm32f4xx_conf.h
